options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: lora_dechirp
    output_language: python
    run_options: run
    title: LoRa dechirp
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: chirp_sf11
  id: variable
  parameters:
    value: np.exp(1j * 2 * np.pi * np.cumsum(np.arange(2**11 * samp_rate // bandwidth) / samp_rate**2 * bandwidth**2 / 2**11 - bandwidth / (2 * samp_rate)))
  states: {}
- name: chirp_sf7
  id: variable
  parameters:
    value: np.exp(1j * 2 * np.pi * np.cumsum(np.arange(2**7 * samp_rate // bandwidth) / samp_rate**2 * bandwidth**2 / 2**7 - bandwidth / (2 * samp_rate)))
  states: {}
- name: chirp_sf9
  id: variable
  parameters:
    value: np.exp(1j * 2 * np.pi * np.cumsum(np.arange(2**9 * samp_rate // bandwidth) / samp_rate**2 * bandwidth**2 / 2**9 - bandwidth / (2 * samp_rate)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '200'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: dechirped.c64
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: not-lora.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: chirp_sf7
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '21'
    interp: '40'
    type: ccc
  states: {}

connections:
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_conjugate_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
