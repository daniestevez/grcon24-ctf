options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: not_lora_generator
    output_language: python
    run_options: run
    title: Not-LoRa generator
  states: {}

blocks:
- name: band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: high_cutoff - ((high_cutoff + low_cutoff)  * sideband)
    low_cutoff_freq: low_cutoff - ((high_cutoff + low_cutoff) * sideband)
    samp_rate: '20000'
    type: complex_band_pass
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: chirp_sf11
  id: variable
  parameters:
    value: np.exp(1j * 2 * np.pi * np.cumsum(np.arange(2**11 * samp_rate // bandwidth) / samp_rate**2 * bandwidth**2 / 2**11 - bandwidth / (2 * samp_rate)))
  states: {}
- name: chirp_sf7
  id: variable
  parameters:
    value: np.exp(1j * 2 * np.pi * np.cumsum(np.arange(2**7 * samp_rate // bandwidth) / samp_rate**2 * bandwidth**2 / 2**7 - bandwidth / (2 * samp_rate)))
  states: {}
- name: chirp_sf9
  id: variable
  parameters:
    value: np.exp(1j * 2 * np.pi * np.cumsum(np.arange(2**9 * samp_rate // bandwidth) / samp_rate**2 * bandwidth**2 / 2**9 - bandwidth / (2 * samp_rate)))
  states: {}
- name: high_cutoff
  id: variable
  parameters:
    value: '2600'
  states: {}
- name: low_cutoff
  id: variable
  parameters:
    value: '250'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2_000_000'
  states: {}
- name: sideband
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '20000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '40000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0_1
  id: analog_nbfm_tx
  parameters:
    audio_rate: '20000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '40000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0_1_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '20000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '40000'
    tau: '75e-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '6'
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: 2**15
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '3127'
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: '18437'
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: '343'
    type: complex
  states: {}
- name: blocks_delay_0_0_0_1
  id: blocks_delay
  parameters:
    delay: '343'
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: solution.cs64
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: not-lora.sigmf-data
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: 2**15
    vector_input: 'False'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.003'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '15'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * np.pi * 163.287e3 / samp_rate
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * np.pi * -147.287e3 / samp_rate
  states: {}
- name: blocks_rotator_cc_1_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2 * np.pi * 127.827 / samp_rate
  states: {}
- name: blocks_rotator_cc_2
  id: blocks_rotator_cc
  parameters:
    phase_inc: '- 2 * np.pi * 77.37e3 / samp_rate'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: 10**(10/20) * chirp_sf9
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: 10**(-10/20) * chirp_sf11
  states: {}
- name: blocks_vector_source_x_0_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: 10**(-17/20) * chirp_sf9
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: chirp_sf7
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: 10**(6/20) * chirp_sf7
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel/contracting/grcon24-ctf/not-lora/flag5.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel/contracting/grcon24-ctf/not-lora/flag1.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_1
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel/contracting/grcon24-ctf/not-lora/flag2.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_1_0
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel/contracting/grcon24-ctf/not-lora/flag3.wav
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_2
  id: blocks_wavfile_source
  parameters:
    file: /home/daniel/contracting/grcon24-ctf/not-lora/flag4.wav
    repeat: 'False'
  states: {}
- name: cessb_clipper_cc_0
  id: cessb_clipper_cc
  parameters:
    clip: '0.05'
  states: {}
- name: cessb_clipper_cc_0_0
  id: cessb_clipper_cc
  parameters:
    clip: '0.05'
  states: {}
- name: cessb_stretcher_cc_0
  id: cessb_stretcher_cc
  parameters: {}
  states: {}
- name: cessb_stretcher_cc_0_0
  id: cessb_stretcher_cc
  parameters: {}
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_1_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: fft_filter_xxx_0_2
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 520e3/2
    decim: '1'
    gain: '10'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 520e3/2
    decim: '1'
    gain: '10'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 1 + 0.72389e-6
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 1 - 1.37532e-6
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_1_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 1 + 3.728734e-6
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_1_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 1 - 1.37532e-6
    type: ccf
  states: {}
- name: pfb_arb_resampler_xxx_0_2
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 1 - 21.237e-6
    type: ccf
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '80'
    interp: '21'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '50'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '50'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '50'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_3
  id: rational_resampler_xxx
  parameters:
    decim: '80'
    interp: '21'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: flag1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: flag2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: flag3
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: flag4
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: flag5
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: flag1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: flag2
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: flag3
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: flag4
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: flag5
  states: {}

connections:
- [analog_nbfm_tx_0_0, '0', rational_resampler_xxx_0_1, '0']
- [analog_nbfm_tx_0_1, '0', rational_resampler_xxx_0_2, '0']
- [analog_nbfm_tx_0_1_0, '0', rational_resampler_xxx_0_2_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_1, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_xx_1_1, '0']
- [blocks_delay_0_0_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_delay_0_0_0_0, '0', pfb_arb_resampler_xxx_0_1_1, '0']
- [blocks_delay_0_0_0_1, '0', blocks_rotator_cc_0, '0']
- [blocks_float_to_complex_0, '0', fft_filter_xxx_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_multiply_xx_1_0_0, '0']
- [blocks_float_to_complex_0_1, '0', fft_filter_xxx_0_2, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [blocks_multiply_xx_1_0, '0', pfb_arb_resampler_xxx_0_1, '0']
- [blocks_multiply_xx_1_0_0, '0', pfb_arb_resampler_xxx_0_1_0, '0']
- [blocks_multiply_xx_1_1, '0', blocks_rotator_cc_1_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_null_source_0_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [blocks_null_source_0_1, '0', blocks_float_to_complex_0_1, '1']
- [blocks_rotator_cc_0, '0', blocks_multiply_xx_1_0, '1']
- [blocks_rotator_cc_0_0, '0', blocks_multiply_xx_1_0_0, '1']
- [blocks_rotator_cc_1_0, '0', pfb_arb_resampler_xxx_0_2, '0']
- [blocks_rotator_cc_2, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_delay_0_0_0, '0']
- [blocks_vector_source_x_0_0_1, '0', blocks_delay_0_0, '0']
- [blocks_vector_source_x_0_1, '0', blocks_delay_0_0_0_0, '0']
- [blocks_vector_source_x_0_2, '0', blocks_delay_0_0_0_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0_0, '0', analog_nbfm_tx_0_0, '0']
- [blocks_wavfile_source_0_1, '0', analog_nbfm_tx_0_1, '0']
- [blocks_wavfile_source_0_1_0, '0', analog_nbfm_tx_0_1_0, '0']
- [blocks_wavfile_source_0_2, '0', blocks_float_to_complex_0_1, '0']
- [cessb_clipper_cc_0, '0', fft_filter_xxx_0_0, '0']
- [cessb_clipper_cc_0_0, '0', fft_filter_xxx_0_0_0, '0']
- [cessb_stretcher_cc_0, '0', fft_filter_xxx_0_1, '0']
- [cessb_stretcher_cc_0_0, '0', fft_filter_xxx_0_1_0, '0']
- [fft_filter_xxx_0, '0', cessb_clipper_cc_0, '0']
- [fft_filter_xxx_0_0, '0', cessb_stretcher_cc_0, '0']
- [fft_filter_xxx_0_0_0, '0', cessb_stretcher_cc_0_0, '0']
- [fft_filter_xxx_0_1, '0', rational_resampler_xxx_0_0, '0']
- [fft_filter_xxx_0_1_0, '0', rational_resampler_xxx_0_0_0, '0']
- [fft_filter_xxx_0_2, '0', cessb_clipper_cc_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_3, '0']
- [pfb_arb_resampler_xxx_0_0, '0', virtual_sink_0_0, '0']
- [pfb_arb_resampler_xxx_0_1, '0', virtual_sink_0_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_1_0, '0', virtual_sink_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0_1_1, '0', low_pass_filter_0_0, '0']
- [pfb_arb_resampler_xxx_0_2, '0', virtual_sink_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_xx_1_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_complex_to_real_0_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_rotator_cc_2, '0']
- [rational_resampler_xxx_0_2, '0', blocks_multiply_xx_0, '1']
- [rational_resampler_xxx_0_2_0, '0', blocks_multiply_xx_1_1, '1']
- [rational_resampler_xxx_0_3, '0', blocks_multiply_conjugate_cc_0, '1']
- [virtual_source_0, '0', blocks_add_xx_0, '1']
- [virtual_source_0_0, '0', blocks_add_xx_0, '2']
- [virtual_source_0_0_0, '0', blocks_add_xx_0, '3']
- [virtual_source_0_0_0_0, '0', blocks_add_xx_0, '4']
- [virtual_source_0_1, '0', blocks_add_xx_0, '5']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
